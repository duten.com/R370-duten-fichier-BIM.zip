Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-01-11T14:55:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 11 14:55:15 2021 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\{1FAD07B8-4589-4082-AAD1-9767A64AEADA}\ifc * Database version: 5507 * Database creation date: Mon Jan 11 14:55:12 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 11 14:55:13 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 11 14:55:13 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFlowController: Brushed Stainless Steel (2)
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Metal_BrushedStainlessSteel
Pset_ManufacturerTypeInformation - ModelReference: Brushed Stainless Steel; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a
Name (Duten_WtrSplyFitngsForWshBsnsAndTrghs_R370:Brushed Stainless Steel:...)
312004
312068
